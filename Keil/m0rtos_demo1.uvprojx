# Keil uVision project m0rtos_demo1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L031G6Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: m0rtos_demo1
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe -c #L -o $L@P.txt
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Demo
    ../: main.c util.h printf.c
  group RTOS
    ../: task.c task.h config.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube LL:COMMON 1.10.0, Device:STM32Cube LL:GPIO 1.10.0, Device:STM32Cube LL:LPUART 1.10.0, Device:STM32Cube LL:PWR 1.10.0, Device:STM32Cube LL:RCC 1.10.0, Device:STM32Cube LL:USART 1.10.0, Device:STM32Cube LL:UTILS 1.10.0, Device:Startup 1.0.0
